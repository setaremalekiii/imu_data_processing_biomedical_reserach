<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32h7-ICM20948-SPI.ewp</path>
  </project>
  <batchBuild />
</workspace>
